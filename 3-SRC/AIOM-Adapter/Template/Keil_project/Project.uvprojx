# Keil uVision project Project.uvprojx, settings and files
target SPQ_APP (6220000::V6.22::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: cmd /c "".\tools\merge_hex.bat" "#h""
  AfterMake: fromelf --bin --output=.\output\update_firmware\app.bin "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L233,APP_FLAG
  c include: ..\;..\..\Firmware\CMSIS\GD\GD32L23x\Include;..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\Utilities;..\..\SPQ;..\..\RTT;..\..\Template;..\..\BSP;..\..\actuator
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\output\app\app.sct
  group Application
    ../: app_main.c boot_main.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group Peripherals
    ../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_exti.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_rcu.c gd32l23x_syscfg.c gd32l23x_usart.c gd32l23x_dbg.c gd32l23x_fmc.c gd32l23x_i2c.c gd32l23x_pmu.c gd32l23x_timer.c gd32l23x_fwdgt.c gd32l23x_adc.c gd32l23x_vref.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l233xx.s
  group Utilities
    ../../Utilities/: gd32l23x_eval.c
  group Doc
    ../: readme.txt
  group BSP
    ../../BSP/: bsp_uart.c bsp_timer.c bsp_flash.c bsp_port.c bsp_cpu.c bsp_log.c bsp.fwdgt.c
  group SPQ
    ../../SPQ/: spq_function.c pc_cmd_handle.c key_cmd_handle.c port_config.c Queque.c
  group RTT
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group IAP
    ../../SPQ/: iap.c
  group actuator
    ../../actuator/: actuator.c delay.c hall.c key_test.c motor.c
target SPQ_BootLoader (6220000::V6.22::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.1.0
  cpu: as above
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L233,BOOTLOADER_FLAG
  c include: ..\;..\..\Firmware\CMSIS\GD\GD32L23x\Include;..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\Utilities;..\..\SPQ;..\..\RTT;..\..\Template;..\..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x2000
  memory RVCT9: RAM 0x20007000 size 0x1000
  scatter file: .\output\bootloader\bootloader.sct
software components: CMSIS:CORE 6.1.0
